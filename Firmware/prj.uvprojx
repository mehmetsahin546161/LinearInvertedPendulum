# Keil uVision project prj.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\Source\Common\Inc;.\Source\Sensors\Inc;.\Source\Signal_Control\Inc;.\Source\DC_Motor\Inc;.\Source\Signal_Proc\Inc;.\Source\Encoder\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F401CCUx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F401CCUx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group STM32CubeMX:Peripheral Sources
    ./RTE/Device/STM32F401CCUx/STCubeGenerated/Src/: gpio.c dma.c tim.c usart.c
  group Common
    ./Source/Common/Src/: app_main.c
  group DC Motor
    ./Source/DC_Motor/Src/: dc_motor.c
  group Signal Control
    ./Source/Signal_Proc/Src/: disc_calc.c pole_placement.c
  group Encoder
    ./Source/Encoder/Src/: encoder.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:Startup 2.6.3
